# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h Int0.h Int0.c Timer0_Init.c Timer0_Init.h IR.h IR.c Timer1_Init .c Timer1_Init .h MOTOR.c MOTOR.h Nixie.h Nixie.c
