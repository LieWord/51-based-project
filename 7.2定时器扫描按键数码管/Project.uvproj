# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h IndeKey.c IndeKey.h Nixie.c Nixie.h Timer0_Init.c Timer0_Init.h AT2402.c AT2402.h I2C.c I2C.h
