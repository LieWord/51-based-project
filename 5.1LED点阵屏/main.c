#include <REGX52.H>
#include "Delay.h"
#include "MatrixLED.h"

unsigned char code Animation[]={
0x98,0x98,0x99,0x01,0x01,0x99,0x98,0x98,
0x98,0x90,0x99,0x01,0x01,0x99,0x90,0x98,
0x98,0xA0,0x9A,0x01,0x01,0x9A,0xA0,0x98,
0x98,0xA0,0x9A,0x01,0x01,0x9A,0xA0,0x98,
0x98,0xA0,0x9A,0x01,0x01,0x9A,0xA0,0x98,
0x98,0x90,0x99,0x01,0x01,0x99,0x90,0x98,
};

void main(){
	unsigned char i,m,offset=0,Count=0;
	MatrixLED_Init();
	while(1){
		for(i=0;i<8;i++){
			MatrixLED(i,Animation[i+offset]);
			//MatrixLED(1,Animation[1]);
			//MatrixLED(2,Animation[2]);
			//MatrixLED(3,Animation[3]);
			//MatrixLED(4,Animation[4]);
			//MatrixLED(5,Animation[5]);
			//MatrixLED(6,Animation[6]);
			//MatrixLED(7,Animation[7]);			
		}
		Count++;
		if(Count>50){
			Count=0;
			offset+=8;
		}

		if(offset>=48){
			offset=0;
		}
	}
}